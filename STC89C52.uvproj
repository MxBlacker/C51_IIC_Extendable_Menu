# Keil uVision project STC89C52.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC89C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Header
  group main
    ./: main.c
  group Header
    ./Header/: stdint.h Soft_I2C.h Soft_I2C.c SSD1306.c SSD1306.h Font.h Menu.c Menu.h
